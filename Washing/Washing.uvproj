# Keil uVision project Washing.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC2131 NXP
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Washing
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group USR
    ./Source/: main.c
  group SOFTWARE
    ./Source/: delay.c countdown.c function.c
  group HARDWARE
    ./Source/: led.c timer.c digitaltube.c beep.c motor.c key.c uart0.c
  group INCLUDE
    ./Include/: delay.h led.h lpc213x.h timer.h TypeDef.h digitaltube.h beep.h function.h CountDown.h motor.h key.h uart0.h
  group SYSTEM
    ./Source/: VIC_INT_CTRL.s Startup.s
